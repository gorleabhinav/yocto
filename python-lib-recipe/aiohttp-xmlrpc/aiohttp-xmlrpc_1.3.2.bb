
DESCRIPTION = "aiohttp XML-RPC server handler and client"
AUTHOR = " Dmitry Orlov"
HOMEPAGE = "https://github.com/mosquito/aiohttp-xmlrpc"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit pypi setuptools3

PR = "r0"

SRC_URI[sha256sum] = "12b124968fa4554e8248d68b1a35b0c54f7dc58f13609fbfc431df4a90de70f8"