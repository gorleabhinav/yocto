
DESCRIPTION = "Schedule python module"
AUTHOR = " Daniel Bader"
HOMEPAGE = "https://github.com/dbader/schedule"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit pypi setuptools3

PR = "r0"

SRC_URI[sha256sum] = "e6ca13585e62c810e13a08682e0a6a8ad245372e376ba2b8679294f377dfc8e4"